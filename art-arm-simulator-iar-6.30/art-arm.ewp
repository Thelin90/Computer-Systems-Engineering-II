# IAR project art-arm.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: art-arm.out
  ILINK.IlinkIcfFile: \\SBS2011\RedirectedFolders\simon\My Documents\Halmstad Högskola\Datorsystemteknik2\grand_grand_grand_finale\olle\art-arm-simulator-iar-6.30\generic.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: calculator.c context.s79 dlist.c dlist.h elevator.c inter_process_communication.c kernel.c kernel.h kernel_hwdep.h kernel_hwdep_sim.c main.c task.c test_no_funcs.c testLeaks.c timer.c
